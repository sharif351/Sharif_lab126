# Keil uVision project My1stRTOS_Prj.uvprojx, settings and files
target nRF52840 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: My1stRTOS_Prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056
  c include: ..\NewRTOS_Prj;.\RTE\FreeRTOS\FreeRTOS\Source\include;.\RTE\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM4_MPU;.\RTE\nRF_Libraries\nRF52832_xxAA;.\RTE\components\libraries\util;.\RTE\components\drivers_nrf\nrf_soc_nosd;.\RTE\config;.\RTE\components\libraries\bsp;.\RTE\components\boards;.\RTE\components\drivers_nrf\hal;.\RTE\components\libraries\button;.\RTE\components\drivers_nrf\clock;.\RTE\components\drivers_nrf\common
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ./: main.c
  group FreeRTOS
    ./RTE/FreeRTOS/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./RTE/FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM4_MPU/: port.c
    ./RTE/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:FreeRTOS 10.2.0, Device:Startup 8.24.1
