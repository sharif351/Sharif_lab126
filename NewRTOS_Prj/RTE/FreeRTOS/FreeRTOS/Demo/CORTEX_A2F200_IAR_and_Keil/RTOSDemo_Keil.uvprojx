# Keil uVision project RTOSDemo_Keil.uvprojx, settings and files
target Blinky (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo_Keil
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\CORTEX_A2F200_IAR_and_Keil;.\MicroSemi_Code\CMSIS;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM3;.\MicroSemi_Code\drivers\mss_gpio;.\MicroSemi_Code\drivers\mss_watchdog;.\MicroSemi_Code\drivers\mss_ace;.\MicroSemi_Code\drivers_config\mss_ace
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group System
    ./MicroSemi_Code/CMSIS/startup_keil/: startus_a2fxxxm3.s
  group Common_Demo_Source
    ../Common/Minimal/: TimerDemo.c BlockQ.c blocktim.c death.c dynamic.c flash.c GenQTest.c QPeek.c recmutex.c semtest.c
  group FreeRTOS_Source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
  group FreeTCPIP(based on uIP)
    ../Common/ethernet/FreeTCPIP/: uip_arp.c psock.c timer.c uip.c
  group Microsemi_Drivers
    ./MicroSemi_Code/drivers/mss_gpio/: mss_gpio.c
    ./MicroSemi_Code/drivers/I2C/: i2c.c
    ./MicroSemi_Code/drivers/mss_ace/: ace_convert.c mss_ace.c
    ./MicroSemi_Code/drivers/mss_ethernet_mac/: crc32.c mss_ethernet_mac.c phy.c
    ./MicroSemi_Code/drivers/OLED/: oled.c
    ./MicroSemi_Code/drivers_config/mss_ace/: ace_config.c
  group Main
    ./: main-blinky.c printf-stdarg.c ParTest.c main-full.c uIP_Task.c
  group CMSIS
    ./MicroSemi_Code/CMSIS/: system_a2fxxxm3.c core_cm3.c
  group Web_Server
    ./WebServer/: httpd-cgi.c
    ../Common/ethernet/FreeTCPIP/apps/httpd/: http-strings.c httpd.c httpd-fs.c
target Full (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: as above
  output: RTOSDemo_Keil
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 2770
  c include: ..\CORTEX_A2F200_IAR_and_Keil;.\MicroSemi_Code\CMSIS;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM3;.\MicroSemi_Code\drivers\mss_gpio;.\MicroSemi_Code\drivers\mss_watchdog;..\Common\include;..\Common\ethernet\FreeTCPIP;..\Common\ethernet\FreeTCPIP\apps\httpd;.\MicroSemi_Code\drivers_config\mss_ace;.\MicroSemi_Code\drivers\I2C;.\MicroSemi_Code\drivers\mss_ace;.\MicroSemi_Code\drivers\mss_ethernet_mac;.\MicroSemi_Code\drivers\OLED;.\WebServer;.\MicroSemi_Code\drivers\mss_timer;..\Common\ethernet\FreeTCPIP\net
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
target Full_with_optimisation (ARM-ADS)
  device: A2F200M3F Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0003FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo_Keil
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 2770
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
