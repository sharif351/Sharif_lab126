# Keil uVision project blinky_FreeRTOS_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 FREERTOS
  c misc: --c99
  c include: ..\..
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.1, nRF_Drivers:nrf_clock 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_soc 4.0.0-2.alpha, Third Parties:RTOS:FreeRTOS 1.0.1-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, Board Support:bsp 11.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_clock 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, Third Parties:RTOS:FreeRTOS_MemMang 1.0.1-2.alpha, nRF_Drivers:nrf_rtc 4.0.0-2.alpha
